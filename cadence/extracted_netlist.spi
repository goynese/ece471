* # FILE NAME: /NFS/STAK/STUDENTS/G/GOYNESE/CADENCE/SIMULATION/FULLADDER/
* HSPICES/EXTRACTED/NETLIST/FULLADDER.C.RAW
* NETLIST OUTPUT FOR HSPICES.
* GENERATED ON FEB 21 15:50:08 2014

* FILE NAME: ECE471_FULLADDER_EXTRACTED.S.
* SUBCIRCUIT FOR CELL: FULLADDER.
* GENERATED FOR: HSPICES.
* GENERATED ON FEB 21 15:50:09 2014.

M22 C_OUT C_IN 16 VDD  TSMC25DP  L=239.99999143598E-9 W=5.76000002183719E-6
+AD=3.45600002608915E-12 AS=3.45600002608915E-12 PD=6.96000006428221E-6
+PS=6.96000006428221E-6 M=1
M23 16 B VDD VDD  TSMC25DP  L=239.99999143598E-9 W=5.76000002183719E-6
+AD=3.45600002608915E-12 AS=3.45600002608915E-12 PD=6.96000006428221E-6
+PS=6.96000006428221E-6 M=1
M24 16 A VDD VDD  TSMC25DP  L=239.99999143598E-9 W=5.76000002183719E-6
+AD=3.45600002608915E-12 AS=3.45600002608915E-12 PD=6.96000006428221E-6
+PS=6.96000006428221E-6 M=1
M25 5 C_OUT 18 VDD  TSMC25DP  L=239.99999143598E-9 W=1.91999993148784E-6
+AD=1.15200004483645E-12 AS=1.15200004483645E-12 PD=3.11999997393286E-6
+PS=3.11999997393286E-6 M=1
M26 18 C_IN VDD VDD  TSMC25DP  L=239.99999143598E-9 W=1.91999993148784E-6
+AD=1.15200004483645E-12 AS=1.15200004483645E-12 PD=3.11999997393286E-6
+PS=3.11999997393286E-6 M=1
M27 18 B VDD VDD  TSMC25DP  L=239.99999143598E-9 W=1.91999993148784E-6
+AD=1.15200004483645E-12 AS=1.15200004483645E-12 PD=3.11999997393286E-6
+PS=3.11999997393286E-6 M=1
M28 18 A VDD VDD  TSMC25DP  L=239.99999143598E-9 W=1.91999993148784E-6
+AD=1.15200004483645E-12 AS=1.15200004483645E-12 PD=3.11999997393286E-6
+PS=3.11999997393286E-6 M=1
M29 C_OUT A 17 VDD  TSMC25DP  L=239.99999143598E-9 W=1.91999993148784E-6
+AD=1.15200004483645E-12 AS=1.15200004483645E-12 PD=3.11999997393286E-6
+PS=3.11999997393286E-6 M=1
M30 17 B VDD VDD  TSMC25DP  L=239.99999143598E-9 W=1.91999993148784E-6
+AD=1.15200004483645E-12 AS=1.15200004483645E-12 PD=3.11999997393286E-6
+PS=3.11999997393286E-6 M=1
M31 5 C_IN 20 VDD  TSMC25DP  L=239.99999143598E-9 W=2.88000001091859E-6
+AD=1.72800001304457E-12 AS=1.72800001304457E-12 PD=4.08000005336362E-6
+PS=4.08000005336362E-6 M=1
M32 20 B 19 VDD  TSMC25DP  L=239.99999143598E-9 W=2.88000001091859E-6
+AD=1.72800001304457E-12 AS=1.72800001304457E-12 PD=4.08000005336362E-6
+PS=4.08000005336362E-6 M=1
M33 19 A VDD VDD  TSMC25DP  L=239.99999143598E-9 W=2.88000001091859E-6
+AD=1.72800001304457E-12 AS=1.72800001304457E-12 PD=4.08000005336362E-6
+PS=4.08000005336362E-6 M=1
M34 15 C_OUT VDD VDD  TSMC25DP  L=239.99999143598E-9 W=4.80000016978011E-6
+AD=2.88000005788103E-12 AS=2.88000005788103E-12 PD=6.00000021222513E-6
+PS=6.00000021222513E-6 M=1
M35 14 5 VDD VDD  TSMC25DP  L=239.99999143598E-9 W=4.80000016978011E-6
+AD=2.88000005788103E-12 AS=2.88000005788103E-12 PD=6.00000021222513E-6
+PS=6.00000021222513E-6 M=1
M36 C_OUT C_IN 1 GND  TSMC25DN  L=239.99999143598E-9 W=2.88000001091859E-6
+AD=1.72800001304457E-12 AS=1.72800001304457E-12 PD=4.08000005336362E-6
+PS=4.08000005336362E-6 M=1
M37 1 B GND GND  TSMC25DN  L=239.99999143598E-9 W=2.88000001091859E-6
+AD=1.72800001304457E-12 AS=1.72800001304457E-12 PD=4.08000005336362E-6
+PS=4.08000005336362E-6 M=1
M38 1 A GND GND  TSMC25DN  L=239.99999143598E-9 W=2.88000001091859E-6
+AD=1.72800001304457E-12 AS=1.72800001304457E-12 PD=4.08000005336362E-6
+PS=4.08000005336362E-6 M=1
M39 5 C_OUT 3 GND  TSMC25DN  L=239.99999143598E-9 W=959.999965743918E-9
+AD=576.000022418227E-15 AS=576.000022418227E-15 PD=2.15999989450211E-6
+PS=2.15999989450211E-6 M=1
M40 4 21 3 GND  TSMC25DN  L=239.99999143598E-9 W=959.999965743918E-9
+AD=576.000022418227E-15 AS=576.000022418227E-15 PD=2.15999989450211E-6
+PS=2.15999989450211E-6 M=1
M41 3 B GND GND  TSMC25DN  L=239.99999143598E-9 W=959.999965743918E-9
+AD=576.000022418227E-15 AS=576.000022418227E-15 PD=2.15999989450211E-6
+PS=2.15999989450211E-6 M=1
M42 3 A GND GND  TSMC25DN  L=239.99999143598E-9 W=959.999965743918E-9
+AD=576.000022418227E-15 AS=576.000022418227E-15 PD=2.15999989450211E-6
+PS=2.15999989450211E-6 M=1
M43 C_OUT A 2 GND  TSMC25DN  L=239.99999143598E-9 W=959.999965743918E-9
+AD=576.000022418227E-15 AS=576.000022418227E-15 PD=2.15999989450211E-6
+PS=2.15999989450211E-6 M=1
M44 2 B GND GND  TSMC25DN  L=239.99999143598E-9 W=959.999965743918E-9
+AD=576.000022418227E-15 AS=576.000022418227E-15 PD=2.15999989450211E-6
+PS=2.15999989450211E-6 M=1
M45 5 C_IN 13 GND  TSMC25DN  L=239.99999143598E-9 W=1.4400000054593E-6
+AD=864.000006522286E-15 AS=864.000006522286E-15 PD=2.64000004790432E-6
+PS=2.64000004790432E-6 M=1
M46 13 A 6 GND  TSMC25DN  L=239.99999143598E-9 W=1.4400000054593E-6
+AD=864.000006522286E-15 AS=864.000006522286E-15 PD=2.64000004790432E-6
+PS=2.64000004790432E-6 M=1
M47 6 B GND GND  TSMC25DN  L=239.99999143598E-9 W=1.4400000054593E-6
+AD=864.000006522286E-15 AS=864.000006522286E-15 PD=2.64000004790432E-6
+PS=2.64000004790432E-6 M=1
M48 15 C_OUT GND GND  TSMC25DN  L=239.99999143598E-9 W=2.40000008489005E-6
+AD=1.44000002894051E-12 AS=1.44000002894051E-12 PD=3.5999998999614E-6
+PS=3.5999998999614E-6 M=1
M49 14 5 GND GND  TSMC25DN  L=239.99999143598E-9 W=2.40000008489005E-6
+AD=1.44000002894051E-12 AS=1.44000002894051E-12 PD=3.5999998999614E-6
+PS=3.5999998999614E-6 M=1

.lib "/nfs/guille/u1/c/cdsmgr/cdsmgr/pdk/CDK1.4/local/models/hspice/public/publicModel/tsmc25dN" NMOS
.lib "/nfs/guille/u1/c/cdsmgr/cdsmgr/pdk/CDK1.4/local/models/hspice/public/publicModel/tsmc25dP" PMOS

* INCLUDE FILES

* END OF NETLIST
.TEMP    25.0000
.OP
.save
.OPTION  INGOLD=2 ARTIST=2 PSF=2
+        PROBE=0
.END
